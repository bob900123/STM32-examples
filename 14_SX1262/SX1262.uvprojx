# Keil uVision project SX1262.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SX1262
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Inc;.\Src;.\CMSIS;.\Inc\Lora;.\Src\Lora
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./Src/: Com_Utils.c Driver_LED.c Driver_ADC.c Driver_USART.c main.c Driver_SPI.c Driver_Lora.c
    ./Src/Lora/: driver_sx1262.c driver_sx1262_interface.c
  group Inc
    ./Inc/: Com_Utils.h Driver_LED.h Driver_ADC.h Driver_USART.h Driver_SPI.h Driver_Lora.h
    ./Inc/Lora/: driver_sx1262.h driver_sx1262_interface.h
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
